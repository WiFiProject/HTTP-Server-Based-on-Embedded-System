# Keil uVision project blinky.uvproj, settings and files
target test (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: test
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: ..\..\..\..;C:\software\tii\TivaWare_C_Series-2.1.2.111;C:\software\tii\CC3100SDK_1.2.0\cc3100-sdk\simplelink\include;C:\software\tii\CC3100SDK_1.2.0\cc3100-sdk\simplelink\source;..\HTTP-Server-Based-on-Embedded-System
  library: MicroLIB
  scatter file: blinky.sct
  link misc: --entry Reset_Handler
  group Source
    ./: board.c cli_uart.c main.c spi.c startup_rvmdk.S user.h
  group Libraries
    C:/software/tii/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
    C:/software/tii/CC3100SDK_1.2.0/cc3100-sdk/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
    C:/software/tii/TivaWare_C_Series-2.1.2.111/sensorlib/rvmdk/: sensorlib.lib
